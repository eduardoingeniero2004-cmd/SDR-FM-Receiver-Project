options:
  parameters:
    author: Ing. Eduardo Alberto Bañales Ramirez
    description: SDR-based RDS subcarrier recovery and digital signal analysis.
    generate_options: qt_gui
    id: Radio_FM
    output_language: python
    title: Radio_FM
  states: {}

blocks:
- name: filtro
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del filtro
    start: '0'
    step: '100'
    stop: '75000'
    value: '57000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: variar_frec
  id: variable_qtgui_range
  parameters:
    label: Frecuencia
    start: '80000000'
    step: '200000'
    stop: '110000000'
    value: '105500000'
  states: {}
- name: velocidad
  id: variable_qtgui_range
  parameters:
    label: Velocidad de sincronizacion
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0628'
    widget: counter
  states: {}
- name: volumen
  id: variable_qtgui_range
  parameters:
    label: Volumen
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: '32000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volumen
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: velocidad
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.0005'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '168.421'
    ted_gain: '0.5'
    ted_type: digital.TED_EARLY_LATE
    type: cc
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '75000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '2000'
    win: window.WIN_BLACKMAN
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: filtro
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,2500,1000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: filtro
    decim: '10'
    samp_rate: samp_rate
    taps: '[1.0]'
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    gain: '1'
    interp: '1'
    samp_rate: '32000'
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: variar_frec
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@2
    name: Diagrama de fase
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: variar_frec
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1
    name: Potencia en frecuencia.
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@3
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@4
    type: complex
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    label1: Tab 1
    label2: Tab 2
    label3: Tab 3
    label4: Tab 4
    num_tabs: '5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: variar_frec
    fftsize: '2048'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0
    int_max: '-10'
    int_min: '-80'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '15'
    interp: '2'
    type: fff
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '1'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '1'
    ntaps: 11*168
    samp_rate: samp_rate/12
    sym_rate: '1187.5'
    type: fir_filter_ccf
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_float_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_costas_loop_cc_0, '0']
- [digital_binary_slicer_fb_0, '0', rds_decoder_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', root_raised_cosine_filter_0, '0']
- [filter_fft_low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [filter_fft_low_pass_filter_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [filter_fft_low_pass_filter_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [osmosdr_source_0, '0', filter_fft_low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, blocks_message_debug_0, print]
- [root_raised_cosine_filter_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
